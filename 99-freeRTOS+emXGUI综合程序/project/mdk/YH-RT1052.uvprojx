# Keil uVision project YH-RT1052.uvprojx, settings and files
target itcm_txt_ram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052DVL6B,SKIP_SYSCLK_INIT,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,X_GUI_USE_FREERTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib\app\base;..\..\libraries\sdmmc\inc;..\..\libraries\sdmmc\port;..\..\libraries\fatfs\fsl_sd_disk;..\..\libraries\fatfs
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_itcm_txt_ram.scf
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group startup
    ./: startup_MIMXRT1052.s
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_iomuxc.h fsl_elcdif.c fsl_lpi2c.c fsl_usdhc.c fsl_cache.c fsl_gpt.c fsl_pxp.c fsl_xbara.c fsl_pwm.c fsl_pit.c fsl_edma.c fsl_sai_edma.c fsl_sai.c fsl_dmamux.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group board
    ../../user/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group user
    ../../user/: main.c gui_drv_cfg.h FreeRTOSConfig.h
  group bsp
    ../../user/bsp/delay/: core_delay.c
    ../../user/bsp/font/: fonts.c
    ../../user/bsp/key/: bsp_key.c
    ../../user/bsp/lcd/: bsp_lcd.c
    ../../user/bsp/led/: bsp_led.c
    ../../user/bsp/systick/: bsp_systick.c
    ../../user/bsp/touch/: bsp_i2c_touch.c bsp_touch_gtxx.c
    ../../user/bsp/sd/: bsp_sd.c
    ../../user/bsp/sd_fatfs_test/: bsp_sd_fatfs_test.c
    ../../user/bsp/PXP/: pxp_drv.c
    ../../user/bsp/pit/: bsp_pit.c
  group fatfs
    ../../libraries/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../libraries/fatfs/fsl_sd_disk/: fsl_sd_disk.c
  group codec
    ../../user/bsp/codec/: bsp_sai.c fsl_codec_common.c fsl_wm8960.c
  group sdmmc
    ../../libraries/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../../libraries/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/RVDS/ARM_CM7/r0p1/: port.c
    ../../FreeRTOS/port/MemMang/: heap_4.c
  group emxgui/arch
    ../../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c
    ../../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emxgui/arch/oem_face
    ../../../emXGUI_Lib/arch/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
  group emxgui/widget
    ../../../emXGUI_Lib/app/widget/: Dropdown_Listbox.c
  group emxgui/resource
    ../../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
    ../../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
    ../../../emXGUI_Lib/app/demo/: 0.c
  group emxgui/drv
    ../../../emXGUI_Lib/drv/: gui_font_port.c gui_fs_port.c gui_input_port.c gui_lcd_port.c gui_log_port.c gui_mem_port.c gui_resource_port.c gui_startup.c gui_touch_port.c gui_picture_port.c
  group emxgui/inc
    ../../../emXGUI_Lib/inc/: def.h emXGUI.h emXGUI_Arch.h emXGUI_JPEG.h emxgui_png.h GUI_Font_XFT.h x_libc.h Web_Color.h x_obj.h Clist.h
  group emxgui/libs
    ../../../emXGUI_Lib/libs/: emXGUI100_MDK_M7.lib libjpeg_MDK_M7.lib libpng_MDK_M7.lib x_libc_MDK_M7.lib x_obj.cpp
  group base_app
    ../../../emXGUI_Lib/app/base/: gui_desktop.c CListMenu.cpp CListMenu.h
    ../../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../../emXGUI_Lib/app/demo/: GUI_DEMO_RectSpeed.c GUI_DEMO_Rotate.cpp
  group base_demo
    ../../../emXGUI_Lib/app/demo/: GUI_Board_App_Desktop.c GUI_DEMO_SlideWindow.c GUI_App_Desktop.c GUI_DEMO_Graphics_Accelerator.c GUI_DEMO_ShowWave.cpp GUI_DEMO_ShowComponent.c
  group tutorial/rgb_led
    ../../../emXGUI_Lib/app/tutorial/rgb_led/: GUI_RGBLED_DIALOG.c RGBLED_DIALOG_STYLE.c RGBLED_DIALOG_BACKEND.c
  group tutorial/nes
    ../../../emXGUI_Lib/app/tutorial/nes/InfoNes/InfoNES_v0.97J_RC1/: K6502.cpp InfoNES.cpp InfoNES_Mapper.cpp InfoNES_pAPU.cpp GUI_NES_Dialog.cpp
  group doc
    ../../doc/: 必读说明.txt
  group usb-host-app
    ../../user/bsp/usb/usb_host_app/: host_gamepad.c usb_host_app.c
  group usb-host
    ../../user/bsp/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
  group usb-host-class
    ../../user/bsp/usb/host/class/: usb_host_hid.c usb_host_hub.c usb_host_hub_app.c
  group usb-include
    ../../user/bsp/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb-phy
    ../../user/bsp/usb/phy/: usb_phy.c
  group usb-osa
    ../../user/bsp/usb/osa/: usb_osa_freertos.c
target itcm_txt_sdram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib\app\base
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_itcm_txt_sdram.scf
target sdram_txt_ram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1,CPU_MIMXRT1052DVL6B,SKIP_SYSCLK_INIT,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,X_GUI_USE_FREERTOS,USB_STACK_FREERTOS
  c misc: as above
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\..\emXGUI_Lib\inc;..\..\..\emXGUI_Lib\drv;..\..\..\emXGUI_Lib\arch\Inc;..\..\..\emXGUI_Lib\app\base;..\..\libraries\fatfs;..\..\libraries\fatfs\fsl_sd_disk;..\..\libraries\sdmmc\inc;..\..\libraries\sdmmc\port;..\..\user\bsp\PXP;..\..\..\emXGUI_Lib\app\widget;..\..\..\emXGUI_Lib\app\tutorial\nes;..\..\..\emXGUI_Lib\app\tutorial\nes\InfoNes\InfoNES_v0.97J_RC1;..\..\user\bsp\usb;..\..\user\bsp\usb\host;..\..\user\bsp\usb\include;..\..\user\bsp\usb\host\class;..\..\user\bsp\usb\osa;..\..\user\bsp\usb\phy;..\..\user\bsp\usb\usb_host_app
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_sdram_txt_ram.scf
target nor_txt_ram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052DVL6B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,X_GUI_USE_FREERTOS
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_txt_sdram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USB_STACK_FREERTOS,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1,CPU_MIMXRT1052DVL6B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,X_GUI_USE_FREERTOS,XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, ARM_MATH_CM7,
  c misc: as above
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\..\emXGUI_Lib\arch\Inc;..\..\..\emXGUI_Lib\app\base;..\..\libraries\fatfs;..\..\libraries\fatfs\fsl_sd_disk;..\..\libraries\sdmmc\inc;..\..\libraries\sdmmc\port;..\..\user\bsp\sd_fatfs_test;..\..\..\emXGUI_Lib\inc;..\..\..\emXGUI_Lib\drv;..\..\user\bsp\PXP;..\..\..\emXGUI_Lib\app\tutorial\rgb_led;..\..\..\emXGUI_Lib\app\widget;..\..\..\emXGUI_Lib\app\tutorial\nes;..\..\..\emXGUI_Lib\app\tutorial\nes\InfoNes\InfoNES_v0.97J_RC1;..\..\user\bsp\usb;..\..\user\bsp\usb\host;..\..\user\bsp\usb\include;..\..\user\bsp\usb\host\class;..\..\user\bsp\usb\osa;..\..\user\bsp\usb\phy;..\..\user\bsp\usb\usb_host_app;..\..\user\bsp\codec
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_txt_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_itcm_txt_ram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052DVL6B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,USE_RAM_VECTOR_TABLE,X_GUI_USE_FREERTOS
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_itcm_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_sdram_txt_sdram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib\app\base;..\..\libraries\fatfs;..\..\libraries\fatfs\fsl_sd_disk
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_sdram_txt_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
